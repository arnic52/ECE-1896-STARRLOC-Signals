options:
  parameters:
    author: adam-nichols
    generate_options: qt_gui
    id: ece_1896_nichols_voice_detection
    output_language: python
    title: ECE 1896 Voice Detection from NBFM
  states: {}

blocks:
- name: RF_samp_rate
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '.01'
    stop: '5'
    value: '1'
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: int(147.540e6)
  states: {}
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    start: int(161e6)
    step: int(5e3)
    stop: int(164e6)
    value: int(162.55e6)
  states: {state: disabled}
- name: int_length
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '10'
    step: '1'
    stop: '64'
    value: '40'
  states: {}
- name: thresh
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '.01'
    stop: '1'
    value: '.5'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '256000'
    rate: '1e-4'
    reference: '.5'
    type: complex
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_samp_rate
    max_dev: 5e3
    quad_rate: RF_samp_rate
    tau: '75e-6'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int_length
    type: complex
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int_length
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: thresh
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '800'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 2*3.1415/100
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: carrier_freq
    gain1: '''slow_attack'''
    manual_gain1: rf_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: RF_samp_rate
    type: fc32
    uri: ip:192.168.2.4
  states: {}
- name: qtgui_auto_correlator_sink_0
  id: qtgui_auto_correlator_sink
  parameters:
    fac_decimation: '10'
    fac_size: '512'
    sampRate: RF_samp_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    name: '"Frequency Corrected and AGC''d Baseband Message"'
    size: '1024'
    srate: RF_samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    size: '1024'
    srate: audio_samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"Demodulated FM"'
    size: '1024'
    srate: audio_samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: autocorr_diff
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: NBFM_freq_corrected
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: autocorr_diff
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: NBFM_freq_corrected
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: NBFM_freq_corrected
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_conjugate_cc_0, '0']
- [analog_agc_xx_0, '0', blocks_conjugate_cc_0_0, '0']
- [analog_agc_xx_0, '0', blocks_delay_0, '0']
- [analog_agc_xx_0, '0', blocks_multiply_xx_0, '1']
- [analog_agc_xx_0, '0', qtgui_auto_correlator_sink_0, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_nbfm_rx_0, '0', blocks_multiply_xx_2, '0']
- [blocks_char_to_float_0, '0', blocks_repeat_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_sub_xx_0, '1']
- [blocks_complex_to_mag_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_conjugate_cc_0_0, '0', blocks_multiply_xx_1, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_1, '1']
- [blocks_integrate_xx_0, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_multiply_xx_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_multiply_xx_1, '0', blocks_integrate_xx_0, '0']
- [blocks_multiply_xx_2, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_repeat_0, '0', blocks_multiply_xx_2, '1']
- [blocks_repeat_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_sub_xx_0, '0', virtual_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_1, '0']
- [iio_pluto_source_0, '0', digital_costas_loop_cc_0, '0']
- [virtual_source_0, '0', digital_binary_slicer_fb_0, '0']
- [virtual_source_1, '0', analog_nbfm_rx_0, '0']
- [virtual_source_1_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
